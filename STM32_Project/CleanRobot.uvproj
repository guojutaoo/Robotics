# Keil uVision project CleanRobot.uvproj, settings and files
target CleanArm (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CleanArm +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\CMSIS\CM3\CoreSupport;.\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Hardware\systick;.\Hardware\exti;.\Hardware\time;.\Hardware\pwm;.\Hardware\SCA1000;.\Hardware\printf;.\Hardware\sys;.\Hardware\CAT9555;.\Hardware\ElectricPutter;.\Hardware\RBURF02;.\Hardware\ServoMotor;.\Hardware\usart;.\Hardware\VacuumGenerator;.\Hardware\CleanArm;.\Hardware\BodyMove;.\Hardware\usart;.\Hardware\MNspi;.\Hardware\usart_232
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c public.c
  group CMSIS
    ./Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdperiph_Drive
    ./Library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c
    ./Hardware/sys/: sys.c
  group Hardware
    ./Hardware/systick/: systick.c
    ./Hardware/exti/: exti.c
    ./Hardware/time/: time.c
    ./Hardware/printf/: printf.c
    ./Hardware/SCA1000/: SCA1000.c
    ./Hardware/CAT9555/: iic.c
    ./Hardware/RBURF02/: input.c
    ./Hardware/ServoMotor/: CRC16.c ServoMotor.c
    ./Hardware/ElectricPutter/: ElectricPutter.c
    ./Hardware/VacuumGenerator/: VacuumGenerator.c
    ./Hardware/CleanArm/: CleanArm.c
    ./Hardware/BodyMove/: BodyMove.c
    ./Hardware/MNspi/: MNspi.c
    ./Hardware/usart_232/: usart_232.c
